# Keil uVision project STM_code.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: STM32F303K8Tx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.2.2
  cpu: IRAM(0x20000000,0x00003000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM_code
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x3000
  group Source Group 1
    ./: adc.c leds.c main.c PLL Config STMF3.c usart.c systick_delay.c pwm.c
  group Includes
    ./: PWR.h PLL_Config.h pwm.h adc.h leds.h main.h systick_delay.h usart.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.11.2
